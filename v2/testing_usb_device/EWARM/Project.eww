<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\testing_usb_device.ewp</path>
  </project>
  <batchBuild />
</workspace>
